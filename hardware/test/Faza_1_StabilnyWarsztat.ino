#include <SPI.h>
#include <mcp_can.h>

// --- KONFIGURACJA PINÓW ---
const int SPI_CS_PIN = 10;
const int CAN_INT_PIN = 2;
const int TJA_ERR = 4;
const int TJA_STB = 5;
const int TJA_EN  = 6;

MCP_CAN CAN0(SPI_CS_PIN);

// --- ZMIENNE DIAGNOSTYCZNE ---
unsigned long rxCount = 0;           
unsigned long lastReportTime = 0;
unsigned long lastMessageTime = 0;

void setup() {
  Serial.begin(115200);
  
  // Konfiguracja TJA1055 (Fault-Tolerant CAN)
  pinMode(CAN_INT_PIN, INPUT);
  pinMode(TJA_ERR, INPUT_PULLUP);
  pinMode(TJA_STB, OUTPUT);
  pinMode(TJA_EN, OUTPUT);
  
  digitalWrite(TJA_STB, HIGH);
  digitalWrite(TJA_EN, HIGH);
  delay(100); 

  Serial.println(F("==========================================="));
  Serial.println(F(" FAZA 1: STABILNY WARSZTAT (RADIO 0x61)    "));
  Serial.println(F("==========================================="));

  if (CAN0.begin(MCP_ANY, CAN_100KBPS, MCP_8MHZ) == CAN_OK) {
    
    // 1. Kalibracja timingów VAG (Sample Point ~80%) - z Twojego kodu
    CAN0.mcp2515_setRegister(0x2A, 0x03); 
    CAN0.mcp2515_setRegister(0x29, 0xE8); 
    CAN0.mcp2515_setRegister(0x28, 0x01); 
    
    // 2. Tryb One-Shot (OSM) - bezwzglêdny zakaz retransmisji
    CAN0.mcp2515_modifyRegister(0x0F, 0x08, 0x08); 
    
    CAN0.setMode(MCP_NORMAL); 
    Serial.println(F("SYS: MCP2515 GOTOWY. Czekam na wybudzenie auta..."));
  } else {
    Serial.println(F("ERR: B³¹d inicjalizacji MCP2515!"));
    while (1);
  }
}

void loop() {
  long unsigned int rxId;
  unsigned char len = 0;
  unsigned char rxBuf[8];

  // 3. Brutalne sprzêtowe udra¿nianie buforów i flag b³êdów
  CAN0.mcp2515_modifyRegister(0x2D, 0xFF, 0x00);

  // --- ODBIÓR I REAKCJA ---
  if (!digitalRead(CAN_INT_PIN)) {
    while (CAN0.checkReceive() == CAN_MSGAVAIL) {
      CAN0.readMsgBuf(&rxId, &len, rxBuf);
      rxCount++;
      lastMessageTime = millis();

      // REAKCJA WSTRZYKNIÊCIA (Wyzwalamy siê ramk¹ Sync 0x531)
      if (rxId == 0x531) {
        
        // Formowanie ramki 0x661 (mRadio_4)
        // Bajt 0: 0x01 -> RA4_Radio_on (Radio w³¹czone)
        // Bajt 1: 0x01 -> RA4_Show_Radio (Zezwól na wyœwietlanie)
        unsigned char stRadio[8] = {0x01, 0x01, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00};
        
        // Wys³anie ramki statusowej do Gatewaya
        CAN0.sendMsgBuf(0x661, 0, 8, stRadio);
      }
    }
  }

  // --- DASHBOARD DIAGNOSTYCZNY (Odœwie¿any co 1 sekundê) ---
  if (millis() - lastReportTime >= 1000) {
    lastReportTime = millis();
    unsigned long timeSinceLastMsg = millis() - lastMessageTime;
    
    // Odczyt sprzêtowych liczników b³êdów (dziêki OSM powinno byæ 0)
    byte tec = CAN0.mcp2515_readRegister(0x18); // Transmit Error Counter
    byte rec = CAN0.mcp2515_readRegister(0x19); // Receive Error Counter

    Serial.print(F("Têtno: ")); Serial.print(rxCount); Serial.print(F(" ram/sek | "));
    Serial.print(F("TEC: ")); Serial.print(tec); Serial.print(F(" | REC: ")); Serial.print(rec);
    Serial.print(F(" | Cisza: ")); Serial.print(timeSinceLastMsg); Serial.println(F(" ms"));
    
    if (timeSinceLastMsg > 5000 && rxCount == 0) {
       Serial.println(F("!!! UWAGA: MAGISTRALA ŒPI !!!"));
    }
    rxCount = 0;
  }
}