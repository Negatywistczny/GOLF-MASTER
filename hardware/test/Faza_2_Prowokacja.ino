#include <SPI.h>
#include <mcp_can.h>

// --- KONFIGURACJA PINÓW ---
const int SPI_CS_PIN = 10;
const int CAN_INT_PIN = 2;
const int TJA_ERR = 4;
const int TJA_STB = 5;
const int TJA_EN  = 6;

MCP_CAN CAN0(SPI_CS_PIN);

// --- ZMIENNE DIAGNOSTYCZNE ---
unsigned long lastReportTime = 0;
unsigned long ignitionTimerStart = 0;
bool ignitionDetected = false;
byte currentOpcode = 0x00;
byte currentTarget = 0x00;

void setup() {
  Serial.begin(115200);
  
  pinMode(CAN_INT_PIN, INPUT);
  pinMode(TJA_ERR, INPUT_PULLUP);
  pinMode(TJA_STB, OUTPUT);
  pinMode(TJA_EN, OUTPUT);
  digitalWrite(TJA_STB, HIGH);
  digitalWrite(TJA_EN, HIGH);
  delay(100); 

  Serial.println(F("==============================================="));
  Serial.println(F(" FAZA 2: PROWOKACJA GATEWAYA (SNIFFER OSEK)    "));
  Serial.println(F("==============================================="));

  if (CAN0.begin(MCP_ANY, CAN_100KBPS, MCP_8MHZ) == CAN_OK) {
    CAN0.mcp2515_setRegister(0x2A, 0x03); 
    CAN0.mcp2515_setRegister(0x29, 0xE8); 
    CAN0.mcp2515_setRegister(0x28, 0x01); 
    CAN0.mcp2515_modifyRegister(0x0F, 0x08, 0x08); // One-Shot
    CAN0.setMode(MCP_NORMAL); 
    Serial.println(F("SYS: GOTOWY. Najpierw obudŸ auto BEZ ZAP£ONU."));
  } else {
    Serial.println(F("ERR: B³¹d INIT!"));
    while (1);
  }
}

void loop() {
  long unsigned int rxId;
  unsigned char len = 0;
  unsigned char rxBuf[8];

  // Brutalne sprzêtowe udra¿nianie
  CAN0.mcp2515_modifyRegister(0x2D, 0xFF, 0x00);

  if (!digitalRead(CAN_INT_PIN)) {
    while (CAN0.checkReceive() == CAN_MSGAVAIL) {
      CAN0.readMsgBuf(&rxId, &len, rxBuf);

      // 1. PODTRZYMANIE ZASILANIA (Z Fazy 1)
      if (rxId == 0x531) {
        unsigned char stRadio[8] = {0x01, 0x01, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00};
        CAN0.sendMsgBuf(0x661, 0, 8, stRadio);
      }

      // 2. SNIFFER OSEK NM (Nas³uch na Gateway J533)
      if (rxId == 0x42B) {
        currentTarget = rxBuf[0]; // Do kogo leci token
        currentOpcode = rxBuf[1]; // Jaki jest status sieci

        // Jeœli widzimy rygorystyczny Ring (0x01 lub 0x02), to znaczy ¿e jest zap³on
        if ((currentOpcode == 0x01 || currentOpcode == 0x02) && !ignitionDetected) {
          ignitionDetected = true;
          ignitionTimerStart = millis();
          Serial.println(F("\n!!! WYKRYTO ZAP£ON - GATEWAY URUCHOMI£ PIERŒCIEÑ !!!"));
          Serial.println(F("Rozpoczynam odliczanie 7 sekund... Czekamy na wyrok."));
        }
        
        // Z³apanie b³êdu krytycznego (0x04)
        if (currentOpcode == 0x04 && ignitionDetected) {
           Serial.print(F(">>> ŒMIERÆ SIECI! Stoper (ms): ")); 
           Serial.print(millis() - ignitionTimerStart);
           Serial.println(F(" | Gateway rzuci³ kod 0x04 (Limp Home) <<<"));
           ignitionDetected = false; // Reset logiki
        }
      }
    }
  }

  // --- DASHBOARD DIAGNOSTYCZNY (Co 1s) ---
  if (millis() - lastReportTime >= 1000) {
    lastReportTime = millis();
    
    Serial.print(F("Status Gateway (0x42B): Opcode = 0x"));
    if (currentOpcode < 0x10) Serial.print(F("0"));
    Serial.print(currentOpcode, HEX);
    Serial.print(F(" | Cel = 0x"));
    if (currentTarget < 0x10) Serial.print(F("0"));
    Serial.print(currentTarget, HEX);
    
    if (ignitionDetected) {
      Serial.print(F(" | STOPER: "));
      Serial.print((millis() - ignitionTimerStart) / 1000);
      Serial.println(F(" sek."));
    } else {
      Serial.println();
    }
  }
}