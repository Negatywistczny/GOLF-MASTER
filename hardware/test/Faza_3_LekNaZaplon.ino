#include <SPI.h>
#include <mcp_can.h>

// --- KONFIGURACJA PINÓW ---
const int SPI_CS_PIN = 10;
const int CAN_INT_PIN = 2;
const int TJA_ERR = 4;
const int TJA_STB = 5;
const int TJA_EN  = 6;

MCP_CAN CAN0(SPI_CS_PIN);

// --- ZMIENNE DIAGNOSTYCZNE ---
unsigned long lastReportTime = 0;
unsigned long ignitionTimerStart = 0;
bool ignitionDetected = false;
byte gwOpcode = 0x00;

unsigned long pingsGW = 0; // Ile razy odezwa³ siê Gateway
unsigned long pongsRadio = 0; // Ile razy odes³aliœmy token

void setup() {
  Serial.begin(115200);
  
  pinMode(CAN_INT_PIN, INPUT);
  pinMode(TJA_ERR, INPUT_PULLUP);
  pinMode(TJA_STB, OUTPUT);
  pinMode(TJA_EN, OUTPUT);
  digitalWrite(TJA_STB, HIGH);
  digitalWrite(TJA_EN, HIGH);
  delay(100); 

  Serial.println(F("=================================================="));
  Serial.println(F(" FAZA 3: ZAMKNIÊCIE PIERŒCIENIA (LEK NA ZAP£ON)   "));
  Serial.println(F("=================================================="));

  if (CAN0.begin(MCP_ANY, CAN_100KBPS, MCP_8MHZ) == CAN_OK) {
    CAN0.mcp2515_setRegister(0x2A, 0x03); 
    CAN0.mcp2515_setRegister(0x29, 0xE8); 
    CAN0.mcp2515_setRegister(0x28, 0x01); 
    CAN0.mcp2515_modifyRegister(0x0F, 0x08, 0x08); // One-Shot
    CAN0.setMode(MCP_NORMAL); 
    Serial.println(F("SYS: TARCZE PODNIESIONE. Czekam na w³¹czenie zap³onu..."));
  } else {
    Serial.println(F("ERR: B³¹d INIT!"));
    while (1);
  }
}

void loop() {
  long unsigned int rxId;
  unsigned char len = 0;
  unsigned char rxBuf[8];

  // Brutalne sprzêtowe udra¿nianie
  CAN0.mcp2515_modifyRegister(0x2D, 0xFF, 0x00);

  if (!digitalRead(CAN_INT_PIN)) {
    while (CAN0.checkReceive() == CAN_MSGAVAIL) {
      CAN0.readMsgBuf(&rxId, &len, rxBuf);

      // 1. PODTRZYMANIE ZASILANIA (Zawsze aktywne)
      if (rxId == 0x531) {
        unsigned char stRadio[8] = {0x01, 0x01, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00};
        CAN0.sendMsgBuf(0x661, 0, 8, stRadio);
      }

      // 2. LOGIKA OSEK NM (Reakcja na Token od Gatewaya)
      if (rxId == 0x42B) {
        pingsGW++;
        gwOpcode = rxBuf[1];

        // Start stopera, gdy Gateway wymusza pierœcieñ
        if ((gwOpcode == 0x01 || gwOpcode == 0x02) && !ignitionDetected) {
          ignitionDetected = true;
          ignitionTimerStart = millis();
          Serial.println(F("\n>>> WYKRYTO ZAP£ON. ODSY£AM TOKEN (PING-PONG) <<<"));
        }

        // ==========================================
        // TO JEST LEK NA ZAP£ON (Odes³anie tokenu)
        // ==========================================
        // U¿ywamy oficjalnej ramki radia: NWM_Radio (0x439)
        // Bajt 0: 0x2B (Adres bramki Gateway)
        // Bajt 1: 0x01 (Status: Pierœcieñ Aktywny)
        unsigned char nmRadio[8] = {0x2B, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
        CAN0.sendMsgBuf(0x439, 0, 8, nmRadio);
        pongsRadio++;
        // ==========================================

        // Monitor na wypadek pora¿ki
        if (gwOpcode == 0x04) {
           Serial.println(F("!!! B£¥D PIERŒCIENIA - GATEWAY WYRZUCI£ 0x04 !!!"));
        }
      }
    }
  }

  // --- DASHBOARD DIAGNOSTYCZNY (Co 1s) ---
  if (millis() - lastReportTime >= 1000) {
    lastReportTime = millis();
    
    // Odczyt sprzêtowych b³êdów z krzemu
    byte tec = CAN0.mcp2515_readRegister(0x18);
    byte rec = CAN0.mcp2515_readRegister(0x19);
    
    Serial.print(F("GW Opcode: 0x"));
    if (gwOpcode < 0x10) Serial.print(F("0"));
    Serial.print(gwOpcode, HEX);
    Serial.print(F(" | Pings: ")); Serial.print(pingsGW);
    Serial.print(F(" | Pongs: ")); Serial.print(pongsRadio);
    Serial.print(F(" | TEC/REC: ")); Serial.print(tec); Serial.print(F("/")); Serial.print(rec);
    
    if (ignitionDetected) {
      Serial.print(F(" | ZAP£ON TRWA OD: "));
      Serial.print((millis() - ignitionTimerStart) / 1000);
      Serial.println(F(" s"));
    } else {
      Serial.println();
    }
  }
}