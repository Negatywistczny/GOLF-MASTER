#include <SPI.h>
#include <mcp_can.h>

// --- KONFIGURACJA PINÓW ---
const int SPI_CS_PIN = 10;
const int CAN_INT_PIN = 2;
const int TJA_ERR = 4;
const int TJA_STB = 5;
const int TJA_EN  = 6;

MCP_CAN CAN0(SPI_CS_PIN);

// --- ZMIENNE DIAGNOSTYCZNE ---
unsigned long lastReportTime = 0;
unsigned long pingsGW = 0; 
byte gwOpcode = 0x00;
bool isIgnitionOn = false;

void setup() {
  Serial.begin(115200);
  
  pinMode(CAN_INT_PIN, INPUT);
  pinMode(TJA_ERR, INPUT_PULLUP);
  pinMode(TJA_STB, OUTPUT);
  pinMode(TJA_EN, OUTPUT);
  digitalWrite(TJA_STB, HIGH);
  digitalWrite(TJA_EN, HIGH);
  delay(100); 

  Serial.println(F("=================================================="));
  Serial.println(F(" FAZA 4: CZYSTA EMULACJA RADIA (WÊZE£ 0x61)       "));
  Serial.println(F("=================================================="));

  if (CAN0.begin(MCP_ANY, CAN_100KBPS, MCP_8MHZ) == CAN_OK) {
    CAN0.mcp2515_setRegister(0x2A, 0x03); 
    CAN0.mcp2515_setRegister(0x29, 0xE8); 
    CAN0.mcp2515_setRegister(0x28, 0x01); 
    CAN0.mcp2515_modifyRegister(0x0F, 0x08, 0x08); // One-Shot
    CAN0.setMode(MCP_NORMAL); 
    Serial.println(F("SYS: ZGODNOŒÆ VAG 100%. Nas³uchujê Gatewaya..."));
  } else {
    Serial.println(F("ERR: B³¹d INIT!"));
    while (1);
  }
}

void loop() {
  long unsigned int rxId;
  unsigned char len = 0;
  unsigned char rxBuf[8];

  // Brutalne sprzêtowe udra¿nianie
  CAN0.mcp2515_modifyRegister(0x2D, 0xFF, 0x00);

  if (!digitalRead(CAN_INT_PIN)) {
    while (CAN0.checkReceive() == CAN_MSGAVAIL) {
      CAN0.readMsgBuf(&rxId, &len, rxBuf);

      // =======================================================
      // G£ÓWNY RDZEÑ EMULACJI: Reakcja na bicie serca Gatewaya
      // =======================================================
      if (rxId == 0x42B) {
        pingsGW++;
        gwOpcode = rxBuf[1];

        // Wykrywanie stanu zap³onu na podstawie logiki Gatewaya
        if (gwOpcode == 0x01 || gwOpcode == 0x02) {
          isIgnitionOn = true;
        } else {
          isIgnitionOn = false;
        }

        // AKCJA 1: Podtrzymanie Zasilania (Ramka mRadio_4)
        // Bit 0 = 1 (Radio ON), Bit 1 = 1 (Show Radio)
        unsigned char stRadio[8] = {0x01, 0x01, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00};
        CAN0.sendMsgBuf(0x661, 0, 8, stRadio);

        // AKCJA 2: Zamkniêcie Pierœcienia OSEK NM (Ramka NWM_Radio)
        // Odsy³amy token do Gatewaya (0x2B), potwierdzaj¹c Ring Active (0x01)
        unsigned char nmRadio[8] = {0x2B, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
        CAN0.sendMsgBuf(0x439, 0, 8, nmRadio);
      }
    }
  }

  // --- DASHBOARD DIAGNOSTYCZNY (Co 1s) ---
  if (millis() - lastReportTime >= 1000) {
    lastReportTime = millis();
    
    byte tec = CAN0.mcp2515_readRegister(0x18);
    byte rec = CAN0.mcp2515_readRegister(0x19);
    
    Serial.print(F("ZAP£ON: ")); 
    Serial.print(isIgnitionOn ? F("W£¥CZONY  | ") : F("WY£¥CZONY | "));
    Serial.print(F("GW Opcode: 0x"));
    if (gwOpcode < 0x10) Serial.print(F("0"));
    Serial.print(gwOpcode, HEX);
    
    Serial.print(F(" | Pakiety: ")); Serial.print(pingsGW);
    Serial.print(F(" | B³êdy HW (TEC/REC): ")); Serial.print(tec); Serial.print(F("/")); Serial.println(rec);
    
    if (gwOpcode == 0x04) {
      Serial.println(F("!!! OSTRZE¯ENIE: GATEWAY ZG£ASZA B£¥D PIERŒCIENIA (0x04) !!!"));
    }
  }
}