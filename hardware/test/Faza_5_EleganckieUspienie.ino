#include <SPI.h>
#include <mcp_can.h>

// --- KONFIGURACJA PINÓW ---
const int SPI_CS_PIN = 10;
const int CAN_INT_PIN = 2;
const int TJA_ERR = 4;
const int TJA_STB = 5;
const int TJA_EN  = 6;

MCP_CAN CAN0(SPI_CS_PIN);

// --- ZMIENNE DIAGNOSTYCZNE I STANOWE ---
unsigned long lastReportTime = 0;
unsigned long lastMessageTime = 0;
byte gwOpcode = 0x00;

bool isIgnitionOn = false;
bool isSleeping = false; // G³ówna flaga trybu "Deep Sleep"

void setup() {
  Serial.begin(115200);
  
  pinMode(CAN_INT_PIN, INPUT);
  pinMode(TJA_ERR, INPUT_PULLUP);
  pinMode(TJA_STB, OUTPUT);
  pinMode(TJA_EN, OUTPUT);
  digitalWrite(TJA_STB, HIGH);
  digitalWrite(TJA_EN, HIGH);
  delay(100); 

  Serial.println(F("=================================================="));
  Serial.println(F(" FAZA 5: SYSTEM OSEK NM KOMPLETNY (WÊZE£ 0x61)    "));
  Serial.println(F("=================================================="));

  if (CAN0.begin(MCP_ANY, CAN_100KBPS, MCP_8MHZ) == CAN_OK) {
    CAN0.mcp2515_setRegister(0x2A, 0x03); 
    CAN0.mcp2515_setRegister(0x29, 0xE8); 
    CAN0.mcp2515_setRegister(0x28, 0x01); 
    CAN0.mcp2515_modifyRegister(0x0F, 0x08, 0x08); // One-Shot
    CAN0.setMode(MCP_NORMAL); 
    Serial.println(F("SYS: GOTOWY. Dzia³am w trybie pe³nej automatyki."));
  } else {
    Serial.println(F("ERR: B³¹d INIT!"));
    while (1);
  }
}

void loop() {
  long unsigned int rxId;
  unsigned char len = 0;
  unsigned char rxBuf[8];

  // Brutalne sprzêtowe udra¿nianie
  CAN0.mcp2515_modifyRegister(0x2D, 0xFF, 0x00);

  if (!digitalRead(CAN_INT_PIN)) {
    while (CAN0.checkReceive() == CAN_MSGAVAIL) {
      CAN0.readMsgBuf(&rxId, &len, rxBuf);
      lastMessageTime = millis();

      // =======================================================
      // LOGIKA OSEK NM: Reakcja na komendy z bramki J533
      // =======================================================
      if (rxId == 0x42B) {
        gwOpcode = rxBuf[1];

        // --- TRYB UŒPIENIA (Gateway krzyczy: "Idziemy spaæ!") ---
        if (gwOpcode == 0x10) {
          if (!isSleeping) {
            Serial.println(F("\n[!] GATEWAY ZARZ¥DZI£ UŒPIENIE (0x10). K³adê siê spaæ."));
            isSleeping = true;
            isIgnitionOn = false;
          }
          
          // Odsy³amy ZGODÊ NA SEN (Sleep Acknowledge)
          // Bajt 0: 0x2B, Bajt 1: 0x20
          unsigned char nmSleep[8] = {0x2B, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
          CAN0.sendMsgBuf(0x439, 0, 8, nmSleep);
          
          // UWAGA: Œwiadomie pomijamy wys³anie 0x661!
        } 
        // --- TRYB AKTYWNY (Gateway utrzymuje pierœcieñ lub wybudza) ---
        else if (gwOpcode == 0x01 || gwOpcode == 0x02) {
          if (isSleeping) {
            Serial.println(F("\n[*] WYBUDZENIE SIECI! Wznawiam pe³n¹ symulacjê Radia."));
            isSleeping = false;
          }
          
          isIgnitionOn = (gwOpcode == 0x01);

          // AKCJA 1: Podtrzymanie zasilania
          unsigned char stRadio[8] = {0x01, 0x01, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00};
          CAN0.sendMsgBuf(0x661, 0, 8, stRadio);

          // AKCJA 2: Zamkniêcie pierœcienia (Ring Active)
          unsigned char nmRadio[8] = {0x2B, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
          CAN0.sendMsgBuf(0x439, 0, 8, nmRadio);
        }
      }
    }
  }

  // --- DASHBOARD DIAGNOSTYCZNY ---
  if (millis() - lastReportTime >= 1000) {
    lastReportTime = millis();
    unsigned long timeSinceLastMsg = millis() - lastMessageTime;
    
    if (isSleeping) {
      Serial.print(F("TRYB: NOC | Cisza na kablach od: "));
      Serial.print(timeSinceLastMsg);
      Serial.println(F(" ms | Oczekujê na odciêcie pr¹du przez auto..."));
      
      if (timeSinceLastMsg > 8000) {
        Serial.println(F(">>> AUTO W PE£NI ZASNÊ£O (DEEP SLEEP) <<<"));
      }
    } else {
      byte tec = CAN0.mcp2515_readRegister(0x18);
      byte rec = CAN0.mcp2515_readRegister(0x19);
      Serial.print(F("TRYB: DZIEÑ | ZAP£ON: ")); 
      Serial.print(isIgnitionOn ? F("TAK") : F("NIE"));
      Serial.print(F(" | HW B³êdy: ")); Serial.print(tec); Serial.print(F("/")); Serial.println(rec);
    }
  }
}